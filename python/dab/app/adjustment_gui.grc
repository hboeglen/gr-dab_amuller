options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: gnuradio.dab.app.adjust_gui_helpers.id_to_frequency(frequency_id)
  states: {}
- name: frequency_id
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Frequency
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: gnuradio.dab.app.adjust_gui_helpers.get_number_of_channels()-1
    value: frequency_id_default
  states: {}
- name: gain_bb
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Gain BB
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: gain_bb_default
  states: {}
- name: gain_if
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Gain IF
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: gain_if_default
  states: {}
- name: gain_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain RF
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: gain_rf_default
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    outputmsgname: value
    showports: 'False'
    start: '-1000'
    step: '1'
    stop: '1000'
    value: ppm_default
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 6,0,1,1
    label: Save adjustments to configuration file
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: adjust_gui_helpers
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      table = [
      {'index' : '5A' , 'frequency' : '174.928'},
      {'index' : '5B' , 'frequency' : '176.640'},
      {'index' : '5C' , 'frequency' : '178.352'},
      {'index' : '5D' , 'frequency' : '180.064'},
      {'index' : '6A' , 'frequency' : '181.936'},
      {'index' : '6B' , 'frequency' : '183.648'},
      {'index' : '6C' , 'frequency' : '185.360'},
      {'index' : '6D' , 'frequency' : '187.072'},
      {'index' : '7A' , 'frequency' : '188.928'},
      {'index' : '7B' , 'frequency' : '190.640'},
      {'index' : '7C' , 'frequency' : '192.352'},
      {'index' : '7D' , 'frequency' : '194.064'},
      {'index' : '8A' , 'frequency' : '195.936'},
      {'index' : '8B' , 'frequency' : '197.648'},
      {'index' : '8C' , 'frequency' : '199.360'},
      {'index' : '8D' , 'frequency' : '201.072'},
      {'index' : '9A' , 'frequency' : '202.928'},
      {'index' : '9B' , 'frequency' : '204.640'},
      {'index' : '9C' , 'frequency' : '206.352'},
      {'index' : '9D' , 'frequency' : '208.064'},
      {'index' : '10A', 'frequency' : '209.936'},
      {'index' : '10B', 'frequency' : '211.648'},
      {'index' : '10C', 'frequency' : '213.360'},
      {'index' : '10D', 'frequency' : '215.072'},
      {'index' : '11A', 'frequency' : '216.928'},
      {'index' : '11B', 'frequency' : '218.640'},
      {'index' : '11C', 'frequency' : '220.352'},
      {'index' : '11D', 'frequency' : '222.064'},
      {'index' : '12A', 'frequency' : '223.936'},
      {'index' : '12B', 'frequency' : '225.648'},
      {'index' : '12C', 'frequency' : '227.360'},
      {'index' : '12D', 'frequency' : '229.072'},
      {'index' : '13A', 'frequency' : '230.748'},
      {'index' : '13B', 'frequency' : '232.496'},
      {'index' : '13C', 'frequency' : '234.208'},
      {'index' : '13D', 'frequency' : '235.776'},
      {'index' : '13E', 'frequency' : '237.448'},
      {'index' : '13F', 'frequency' : '239.200'}]


      def get_number_of_channels():
        return len(table)

      def id_to_frequency(i):
        frequency_mhz = float(table[int(i)]['frequency'])
        print(frequency_mhz)
        return frequency_mhz*1e6
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1536'
    type: complex
  states: {}
- name: dab_ofdm_demod_0
  id: dab_ofdm_demod
  parameters:
    autocorr_sr: 'False'
    correct_ffe: 'True'
    dab_mode: '1'
    eq_mag: 'True'
    input_fft: 'True'
    ppm_error: ppm
    samp_rate: samp_rate
    soft_bits: soft
  states: {}
- name: dab_osmo_or_zmq_source_0
  id: dab_osmo_or_zmq_source
  parameters:
    bb_gain: gain_bb
    frequency: frequency
    from_file: from_file
    from_file_repeat: from_file_repeat
    if_gain: gain_if
    rf_gain: gain_slider
    samp_rate: samp_rate
    server: server
    server_control: server_control
    zeromq: zeromq
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: frequency_id_default
  id: parameter
  parameters:
    value: '18'
  states: {}
- name: from_file
  id: parameter
  parameters:
    value: None
  states: {}
- name: from_file_repeat
  id: parameter
  parameters:
    value: 'False'
  states: {}
- name: gain_bb_default
  id: parameter
  parameters:
    value: '10'
  states: {}
- name: gain_if_default
  id: parameter
  parameters:
    value: '10'
  states: {}
- name: gain_rf_default
  id: parameter
  parameters:
    value: '33'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.dab.app.adjust_gui_helpers
  states: {}
- name: ppm_default
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 5,1,5,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: 0,1,5,1
    showports: 'True'
    type: complex
  states: {}
- name: server
  id: parameter
  parameters:
    value: '"tcp://127.0.0.1:10444"'
  states: {}
- name: server_control
  id: parameter
  parameters:
    value: '"tcp://127.0.0.1:10445"'
  states: {}
- name: zeromq
  id: parameter
  parameters:
    value: 'False'
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [dab_ofdm_demod_0, '0', blocks_vector_to_stream_0, '0']
- [dab_osmo_or_zmq_source_0, '0', dab_ofdm_demod_0, '0']
- [dab_osmo_or_zmq_source_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', qtgui_const_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
